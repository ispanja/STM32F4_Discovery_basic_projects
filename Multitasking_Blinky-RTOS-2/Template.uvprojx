# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER, HSE_VALUE=8000000
  c include: .\;Lib\CMSIS\Include;Lib\CMSIS\Device\ST\STM32F4xx\Include;Lib\STM32F4xx_StdPeriph_Driver\inc;FreeRTOS\include;FreeRTOS\portable\keil\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group BSP
    ./: stm32f4xx_conf.h stm32f4_discovery.c stm32f4_discovery.h
    ./Lib/CMSIS/Device/ST/STM32F4xx/Include/: system_stm32f4xx.h
    ./Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group STM_lib
    ./: STM_Peripheral_Lib_v1.7.1.lib
  group Source
    ./: main.c gpio.c
  group Header
    ./: main.h gpio.h
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/keil/ARM_CM4F/: port.c
    ./FreeRTOS/include/: FreeRTOSConfig.h
    ./FreeRTOS/portable/MemMang/: heap_2.c
software components: CMSIS:CORE 5.1.2
